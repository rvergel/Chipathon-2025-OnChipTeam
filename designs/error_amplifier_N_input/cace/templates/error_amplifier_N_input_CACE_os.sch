** sch_path: designs/error_amplifier_N_input/cace/templates/error_amplifier_N_input_CACE_os.sch
**.subckt error_amplifier_N_input_CACE_os
V1 Vref GND CACE{Vref}
* noconn #net1
V8 VDD GND CACE{VDD}
V5 VSS GND 0
C1 Vout GND 5p m=1
Vsweep Vout Vx CACE{Vsweep}
V3 Vn Vx CACE{Vref}
x1 Vout Vref Vn Vref VDD VSS net1 error_amplifier_N_input
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1






.control
save all

** OP simulation
op
** Output swing
dc Vsweep 0 1.8 0.01

setplot dc1
let dvout = deriv(v(Vout))

meas dc limmin when dvout=0.98 rise=1
meas dc limmax when dvout=0.98 fall=1

let Output_swing = limmax - limmin

*print Output_swing
*plot dvout

print Output_swing
echo $&Output_swing > CACE{simpath}/CACE{filename}_CACE{N}.data


.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
