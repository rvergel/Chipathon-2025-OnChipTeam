** sch_path: designs/error_amplifier_N_input/cace/templates/error_amplifier_N_input_CACE_ac.sch
**.subckt error_amplifier_N_input_CACE_ac
V5 Vn Vx AC 1
C2 Vx Vref 10G m=1
L4 Vy Vx 10G m=1
C1 Vout GND 5p m=1
V9 Vz Vy CACE{Vy}
E1 Vz GND Vout GND 1
V0 VSS GND 0
V10 net1 GND CACE{VDD}
V11 Vref GND CACE{Vref}
vdd_i net1 VDD 0
.save i(vdd_i)
* noconn #net2
x1 Vout Vref Vn Vref VDD VSS net2 error_amplifier_N_input
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1





.control
save all

*DC simulation
op
* run ac simulation
ac dec 20 1 100e7


* measure parameters
let vout_mag = db(abs(v(Vout)))
*let vout_phase = cph(v(Vout)) * (180/pi)
let vout_phase = cph(v(Vout)) * (57.295779513)
let gm = (-1)*db(abs(v(Vout)))

meas ac A0 find vout_mag at=1
meas ac UGB when vout_mag=0 fall=1
meas ac PM find vout_phase when vout_mag=0
meas ac GM find gm when vout_phase=0

let A0_p1 = A0 - 3
meas ac BW when vout_mag=A0_p1

print A0 UGB PM GM BW
echo $&A0 $&UGB $&PM $&GM $&BW > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
