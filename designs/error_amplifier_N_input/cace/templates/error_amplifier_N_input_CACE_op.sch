** sch_path: designs/error_amplifier_N_input/cace/templates/error_amplifier_N_input_CACE_op.sch
**.subckt error_amplifier_N_input_CACE_op
C1 Vout VSS 5p m=1
* noconn #net2
V0 VSS GND 0
V1 net1 GND CACE{VDD}
V3 Vref GND CACE{Vref}
vdd_i net1 VDD 0
.save i(vdd_i)
V9 Vz Vn CACE{Vy}
E1 Vz GND Vout GND 1
x1 Vout Vref Vn Vref VDD VSS net2 error_amplifier_N_input
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
save all

*DC simulation
op

let Vout = v(Vout)
let Power = i(vdd_i)*v(VDD)

print Vout Ivdd
echo $&Vout $&Power> CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
