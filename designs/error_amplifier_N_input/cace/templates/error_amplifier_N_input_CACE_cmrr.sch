** sch_path: designs/error_amplifier_N_input/cace/templates/error_amplifier_N_input_CACE_cmrr.sch
**.subckt error_amplifier_N_input_CACE_cmrr
V5 V+ Vref AC 1
C3 V- V+ 10G m=1
L2 Vout V- 10G m=1
* noconn #net1
C4 Vout GND 5p m=1
V8 VDD GND CACE{VDD}
V9 VSS GND 0
V1 Vref GND CACE{Vref}
x1 Vout V+ V- Vref VDD VSS net1 error_amplifier_N_input
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1






.control
save all

** OP simulation
op

** run ac simulation
ac dec 20 1 100e6

setplot ac1

* measure parameters
let vout_mag = db(abs(v(Vout)))
let vout_phase = cph(v(Vout)) * 180/pi

meas ac Acm find vout_mag at=1

*plot vout_mag vout_phase

print Acm
echo $&Acm > CACE{simpath}/CACE{filename}_CACE{N}.data


.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
