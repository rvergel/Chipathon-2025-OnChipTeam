** sch_path: designs/current_reference_load/cace/templates/CR_loads_jangarita.sch
**.subckt CR_loads_jangarita
x1 Iref1n Iref10n Iref1p Iref10p VDD VSS current_reference_load
I4 Iref1n VSS 1u
VSN VSS GND 0
VSP VDD GND CACE{VDD}
I1 VDD Iref1p 1u
I2 VDD Iref10p 10u
I3 Iref10n VSS 10u
**** begin user architecture code



* .param VDD=1.8
.save

.control
	save all
	op
	* write CR_loads_jangarita.raw
	* print v(Iref10n) v(Iref1n) v(Iref1p) v(Iref10p)

	let VIref10n=v(Iref10n)
	let VIref1n=v(Iref1n)
	let VIref10p=v(Iref10p)
	let VIref1p=v(Iref1p)

	set wr_singlescale
	echo $&VIref10n $&VIref1n $&VIref10p $&VIref1p > CACE{simpath}/CACE{filename}_CACE{N}.data
	.endc





.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends

* expanding   symbol:  /foss/designs/chipathon_2025/designs/current_reference_load/xschem/current_reference_load.sym # of pins=6
** sym_path: /foss/designs/chipathon_2025/designs/current_reference_load/xschem/current_reference_load.sym
** sch_path: /foss/designs/chipathon_2025/designs/current_reference_load/xschem/current_reference_load.sch
.subckt current_reference_load Iref1n Iref50n Iref1p Iref50p VDD VSS
*.ipin Iref1n
*.iopin VDD
*.iopin VSS
*.ipin Iref50n
*.ipin Iref1p
*.ipin Iref50p
XM1 Iref1n Iref1n VDD VDD pfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM3 Iref1p Iref1p VSS VSS nfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM2 Iref50n Iref50n VDD VDD pfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=50
XM4 Iref50p Iref50p VSS VSS nfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=50
.ends

.GLOBAL GND
.end
