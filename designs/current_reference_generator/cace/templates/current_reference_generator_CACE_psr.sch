** sch_path: designs/current_reference_generator/cace/templates/current_reference_generator_CACE_psr.sch
**.subckt current_reference_generator_CACE_psr
R2 Vout VSS 600k tc1=200e-6 m=1
* noconn #net6
V3 VSS GND 0
V6 net7 GND CACE{VDD}
V7 Vref GND CACE{Vref}
x1 Vrefp Vout Vref Vref VDD VSS net1 error_amplifier_N_input
x2 net1 Vout VSS VDD Vrefp net6 net3 net2 net4 net5 current_reference_second_stage
x3 net3 net2 net4 net5 VDD VSS current_reference_load
V5 VDD net7 AC 1
**** begin user architecture code


.save all
.save @m.x2.xm7.m0[id]
.save @m.x2.xm8.m0[id]
.save @m.x2.xm3.m0[id]
.save @m.x2.xm4.m0[id]
.control

*AC simulation
ac dec 10 1 10e9

let Iref_1n = db(@m.x2.xm7.m0[id])
let Iref_50n = db(@m.x2.xm8.m0[id])
let Iref_1p = db(@m.x2.xm3.m0[id])
let Iref_50p = db(@m.x2.xm4.m0[id])

meas ac psr_1n find Iref_1n at=10
meas ac psr_50n find Iref_50n at=10
meas ac psr_1p find Iref_1p at=10
meas ac psr_50p find Iref_50p at=10

set wr_singlescale
*set wr_vecnames
echo $&psr_1n $&psr_50n $&psr_1p $&psr_50p > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
