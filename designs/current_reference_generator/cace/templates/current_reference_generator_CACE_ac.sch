** sch_path: designs/current_reference_generator/cace/templates/current_reference_generator_CACE_ac.sch
**.subckt current_reference_generator_CACE_ac
V5 net6 net7 AC 1
C2 net7 Vref 10G m=1
L4 Vout net7 10G m=1
R1 Vout VSS 600k tc1=200e-6 m=1
* noconn #net8
V1 VSS GND 0
V3 VDD GND CACE{VDD}
V6 Vref GND CACE{Vref}
x1 Vrefp net6 Vref Vref VDD VSS net1 error_amplifier_N_input
x2 net1 Vout VSS VDD Vrefp net8 net3 net2 net4 net5 current_reference_second_stage
x3 net3 net2 net4 net5 VDD VSS current_reference_load
**** begin user architecture code


.save all
.control
save all

*AC simulation
ac dec 10 1 10e9

* measure parameters
    let vout_mag = db(abs(v(Vout)))
    let vout_phase = cph(v(Vout)) * 180/pi
    let gm = (-1)*db(abs(v(Vout)))

    meas ac A0 find vout_mag at=10
    meas ac UGB when vout_mag=0 fall=1
    meas ac PM find vout_phase when vout_mag=0
    meas ac GM find gm when vout_phase=0

set wr_singlescale
*set wr_vecnames
echo $&A0 $&UGB $&PM $&GM > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
