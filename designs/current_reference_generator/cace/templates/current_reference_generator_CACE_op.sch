** sch_path: designs/current_reference_generator/cace/templates/current_reference_generator_CACE_op.sch
**.subckt current_reference_generator_CACE_op
R1 V_rext VSS 600k tc1=200e-6 m=1
V1 VSS GND 0
V3 net5 GND CACE{VDD}
V5 Vref GND CACE{Vref}
vdd_i net5 VDD 0
.save i(vdd_i)
x1 VSS VDD Vref Vrefp Vrefn net2 net1 net3 net4 V_rext current_reference_generator
x2 net2 net1 net3 net4 VDD VSS current_reference_load
**** begin user architecture code


.control
save all

*OP simulation
op

*TOP

let Iref_1n = @m.x1.x2.xm7.m0[id]
let Iref_50n = @m.x1.x2.xm8.m0[id]
let Iref_1p = @m.x1.x2.xm3.m0[id]
let Iref_50p = @m.x1.x2.xm4.m0[id]
let Iqscnt= i(vdd_i) - (Iref_1n + Iref_50n + Iref_1p + Iref_50p)
*let Rext = v(V_rext)/i(rext_i)

echo $&Iref_1n $&Iref_50n $&Iref_1p $&Iref_50p $&Iqscnt > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
